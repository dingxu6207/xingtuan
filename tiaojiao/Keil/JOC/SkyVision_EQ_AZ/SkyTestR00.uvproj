# Keil uVision project SkyTestR00.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2148 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: skv_ascom +hex
  c flags: Optim=1
  c include: ..\SkyVision_EQ_AZ
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s main.c ASCOM.c UTR0.c Tst.c Timers.c TelescopeControl.c Sys.c starstructure.c ROM.c PowerUp.c Planet.c MoonPhase.c menu.c LCD12864.C Keys.c JDTime.c Interrupt.c FAS.c EarthPosition.c DispPole.c Disp.c
